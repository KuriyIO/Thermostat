# IAR project Thermostat.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Thermostat.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 1
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: Thermostat.out
  group headers
    source/: buttons.h delay.h HD44780.h main.h menu.h power.h RTC.h sleep.h thermistor.h
  group source
    source/: buttons.c delay.c HD44780.c menu.c power.c RTC.c sleep.c thermistor.c
    ./: main.c
